# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test02 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Timer0.c Nixie.c Key.c AT24C02.c I2C.c LCD1602.c
    ../AT24C02/: AT24C02.c Delay.c I2C.c Key.c LCD1602.c
